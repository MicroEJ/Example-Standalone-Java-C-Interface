# Keil uVision project Project.uvprojx, settings and files
target STM32746G_DISCOVERY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.1.2.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x1000) IRAM2(0x10000000,0x4000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G_DISCOVERY
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCOVERY
  c misc: --C99 --diag_error=223 --fpmode=ieee_no_fenv --apcs=/hardfp
  c include: ..\inc;..\includeAPIs;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32746G-Discovery;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Utilities\Log;..\..\..\..\..\Utilities\Fonts;..\..\..\..\..\Utilities\CPU;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include;..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4;..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\posix;..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\Middlewares\Third_Party\LwIP\system\\OS;..\..\..\..\..\Middlewares\Third_Party\wolfssl;..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\inc-net;..\inc-ssl;..\inc-fs;..\inc-comm;..\inc-ui;..\inc-kf;..\inc-hal;..\..\..\..\..\..\ProducerConsumerData\src\main\c;..\..\..\..\..\..\ProducerConsumerUsingShieldedPlug\src\main\c;..\..\..\..\..\..\ProducerConsumerUsingQueues\src\main\c;..\..\..\..\..\..\NativeQueueWrapper\src\main\c
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\STM32746G_DISCOVERY_qspi.sct
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cec.c stm32f7xx_hal_msp_template.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_eth.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sai.c stm32f7xx_hal_sd.c stm32f7xx_hal_qspi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_usart.c stm32f7xx_hal_irda.c stm32f7xx_hal_pcd.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_rtc.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_smartcard.c stm32f7xx_hal.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_nand.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash.c stm32f7xx_hal_adc.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_nor.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_hash.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dac.c stm32f7xx_hal_hcd.c stm32f7xx_hal_crc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_i2s.c stm32f7xx_ll_usb.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2c.c stm32f7xx_hal_can.c stm32f7xx_hal_ltdc.c
  group Drivers/BSP/STM32746G_DISCOVERY
    ../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_ts.c stm32746g_discovery.c stm32746g_discovery_sdram.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_qspi.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c event_groups.c list.c queue.c tasks.c croutine.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group STM32_USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group STM32_USBH_Library/Class/CDC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
  group MicroEJ/Core
    ../src/: cpuload.c cpuload_impl_FreeRTOS.c fault_handlers.c hooks_FreeRTOS.c interrupts.c LLBSP_stm32.c LLMJVM_FreeRTOS.c LLSP_FreeRTOS.c main.c microjvm_main.c misc.c os_support.c putchar.c stm32f7xx_hal_FreeRTOS.c stm32f7xx_it.c time_hardware_timer.c usbh_conf.c retarget.c math.c LLDEVICE.c
    ./: startup_stm32f746xx.s
  group MicroEJ/Libs
    C:/Workspaces/_GitLab/Example-Standalone-Java-C-Interface/STM32F746GDISCO-SNI_SP-CM7hardfp_ARMCC5-2.1.1/source/lib/: microejruntime.lib
    C:/Workspaces/_GitLab/Example-Standalone-Java-C-Interface/.microej/CM7hardfp_ARMCC5/application/: microejapp.o
  group Production
    ../../../../../../NativeQueueWrapper/src/main/c/: LLNativeQueueService.c
    ../../../../../../ProducerConsumerData/src/main/c/: accelerometer-data.c
    ../../../../../../ProducerConsumerUsingQueues/src/main/c/: sni-producer-accelerometer.c sni-producer-factory.c
    ../../../../../../ProducerConsumerUsingShieldedPlug/src/main/c/: sp-producer-accelerometer.c sp-producer-factory.c
