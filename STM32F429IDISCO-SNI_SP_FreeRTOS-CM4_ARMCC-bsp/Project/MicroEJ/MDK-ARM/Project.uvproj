# Keil uVision project Project.uvproj, settings and files
target STM32F429i-DISCO (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2003FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32429I-DISCO +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --c99 --apcs=/softfp
  c include: ..\inc;..\includeAPIs;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\DeviceSupport\ST\STM32F4xx;..\..\..\Utilities\STM32F429I-Discovery;..\includeAPIs\intern;..\include;..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\SNI-SP\inc;..\..\..\..\ProducerConsumerData\src\main\c;..\..\..\..\ProducerConsumerUsingShieldedPlug\src\main\c;..\..\..\..\ProducerConsumerUsingSNIAndImmortals\src\main\c;..\..\..\..\NativeQueueWrapper\src\main\c
  asm misc: --apcs=/softfp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32429I-DISCO.sct
  link misc: --apcs=/softfp
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_ltdc.c stm32f4xx_fmc.c stm32f4xx_dma2d.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group MicroEJ
    ../src/: fault_handlers.c hooks_FreeRTOS.c interrupts.c LLBSP_stm32.c LLMJVM_FreeRTOS.c main.c microjvm_main.c putchar.c stm32f4xx_it.c system_stm32f4xx.c time_hardware_timer.c math.c LLSP_FreeRTOS.c
  group libs
    C:/Users/Xavier Sautejeau/Documents/workspaces-MicroEJ-DEV-3.1.1/Example-Java-C-Interface/STM32F429IDISCO-SNI_SP_FreeRTOS-CM4_ARMCC-1.0.0/source/lib/: javaruntime.lib
    C:/Users/Xavier Sautejeau/Documents/workspaces-MicroEJ-DEV-3.1.1/Example-Java-C-Interface/.microej/CM4_ARMCC/application/: javaapp.o
  group STM32F4-Discovery
    ../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery_sdram.c stm32f429i_discovery.c stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_ioe.c stm32f429i_discovery_l3gd20.c stm32f429i_discovery_lcd.c
  group FreeRTOS
    ../../FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Production
    ../../../../NativeQueueWrapper/src/main/c/: LLNativeQueueService.c
    ../../../../ProducerConsumerData/src/main/c/: accelerometer-data.c messenger-data.c
    ../../../../ProducerConsumerUsingShieldedPlug/src/main/c/: sp-producer.c sp-producer-accelerometer.c sp-producer-factory.c
    ../../../../ProducerConsumerUsingSNIAndImmortals/src/main/c/: sni-producer.c sni-producer-accelerometer.c sni-producer-factory.c sni-producer-messenger.c
